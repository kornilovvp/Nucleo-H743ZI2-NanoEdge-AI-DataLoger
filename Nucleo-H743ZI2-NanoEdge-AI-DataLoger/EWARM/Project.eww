<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nucleo-H743ZI2-NanoEdge-AI-DataLoger.ewp</path>
  </project>
  <batchBuild />
</workspace>
